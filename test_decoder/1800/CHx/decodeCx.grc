<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gsm_symb_rate</value></param>
<param><key>value</key><value>1625000.0/6.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>value</key><value>gsm_symb_rate*osr</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>b</value></param>
<param><key>label</key><value>Band width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>base_port</value></param>
<param><key>label</key><value>base_port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>6700</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_1</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_2</value></param>
<param><key>samples_per_second</key><value>s</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_2_0</value></param>
<param><key>samples_per_second</key><value>s</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>Frequency Center</value></param>
<param><key>value</key><value>[1847.1e6]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fn</value></param>
<param><key>label</key><value>Frame Number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>gsm_burst_sdcch_subslot_filter</key>
<param><key>id</key><value>gsm_burst_sdcch_subslot_filter_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>mode</key><value>grgsm.SS_FILTER_SDCCH8</value></param>
<param><key>subslot</key><value>3</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_file_source_C0</key>
<param><key>id</key><value>gsm_file_source_C0_0</value></param>
<param><key>f</key><value>1847100000</value></param>
<param><key>offset</key><value>sample_start</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>uplink</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_source_C0</key>
<param><key>id</key><value>gsm_file_source_C0_0_0</value></param>
<param><key>f</key><value>1847100000</value></param>
<param><key>offset</key><value>sample_start</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>uplink</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_source_C0</key>
<param><key>id</key><value>gsm_file_source_C0_0_8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>f</key><value>1851400000</value></param>
<param><key>offset</key><value>(int)(s1/(s)*sample_start)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>uplink</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_hopping_frequency</key>
<param><key>id</key><value>gsm_hopping_frequency_0</value></param>
<param><key>bd</key><value>s</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>hsn</key><value>hsn</value></param>
<param><key>id_start</key><value>id_start</value></param>
<param><key>cell_allocation</key><value>ma</value></param>
<param><key>maio</key><value>maio</value></param>
<param><key>num_streams</key><value>nstream</value></param>
<param><key>samp_in</key><value>s</value></param>
<param><key>sample_rate</key><value>s</value></param>
<param><key>table_name</key><value>n</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_0</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>False</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_sdcch8_demapper</key>
<param><key>id</key><value>gsm_sdcch8_demapper_0</value></param>
<param><key>timeslot_nr</key><value>tslot</value></param>
</block>
<block>
<key>gsm_super_block</key>
<param><key>id</key><value>gsm_super_block_0</value></param>
<param><key>hsn</key><value>hsn</value></param>
<param><key>id_start</key><value>id_start</value></param>
<param><key>cell_allocation</key><value>ma</value></param>
<param><key>maio</key><value>maio</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>sample_rate</key><value>s</value></param>
<param><key>table_name</key><value>726</value></param>
<param><key>tseq</key><value>tseq</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hsn</value></param>
<param><key>label</key><value>hsn</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>id_start</value></param>
<param><key>label</key><value>ID start</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ma</value></param>
<param><key>label</key><value>MA list</value></param>
<param><key>value</key><value>[724,727]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>maio</value></param>
<param><key>label</key><value>maio</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>math_imp</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n</value></param>
<param><key>label</key><value>Database name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>726</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nstream</value></param>
<param><key>label</key><value>Number Stream</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OSR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>10</value></param>
<param><key>rrate</key><value>1625000*2/(6e6*0.8)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>1625000*2/(6e6*0.8)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, s,125e3,5e3,firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, s,125e3,5e3,firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>s</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_start</value></param>
<param><key>label</key><value>Sample Start</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>271850</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tseq</value></param>
<param><key>label</key><value>Traning Sequence</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tslot</value></param>
<param><key>label</key><value>Time Slot</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6</value></param>
</block>
<connection><source_block_id>blocks_throttle_0_2</source_block_id><sink_block_id>gsm_hopping_frequency_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2_0</source_block_id><sink_block_id>gsm_hopping_frequency_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gsm_burst_sdcch_subslot_filter_0</source_block_id><sink_block_id>blocks_socket_pdu_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_burst_sdcch_subslot_filter_0</sink_block_id><source_key>msgs</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_file_source_C0_0</source_block_id><sink_block_id>blocks_throttle_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_file_source_C0_0_0</source_block_id><sink_block_id>blocks_throttle_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_hopping_frequency_0</source_block_id><sink_block_id>pfb_decimator_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_hopping_frequency_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_sdcch8_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_super_block_0</source_block_id><sink_block_id>gsm_sdcch8_demapper_0</sink_block_id><source_key>CX</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>gsm_super_block_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>gsm_super_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
