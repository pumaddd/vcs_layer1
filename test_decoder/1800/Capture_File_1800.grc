<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gsm_symb_rate</value></param>
<param><key>value</key><value>1625000.0/6.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>value</key><value>gsm_symb_rate*osr</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>b</value></param>
<param><key>label</key><value>Band width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>base_port</value></param>
<param><key>label</key><value>base_port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>6700</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f</value></param>
<param><key>label</key><value>File Path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/datqm/Desktop/Share_Folder/Share_Folder/test_613.cfile</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>Frequency Center</value></param>
<param><key>value</key><value>[1856.4e6,1856.4e6+5e6,1856.4e6 + 10e6,1856.4e6-10e6,1856.4-5e6]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fn</value></param>
<param><key>label</key><value>Frame Number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>gsm_decimator_ccf</key>
<param><key>id</key><value>gsm_decimator_ccf_1</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>samp_delay</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, samp_rate/10, 5e3,firdes.WIN_HAMMING,6.76)</value></param>
<param><key>fft_filts</key><value>True</value></param>
<param><key>fft_rot</key><value>True</value></param>
</block>
<block>
<key>gsm_decimator_ccf</key>
<param><key>id</key><value>gsm_decimator_ccf_2</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>samp_delay</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, samp_rate/10, 5e3,firdes.WIN_HAMMING,6.76)</value></param>
<param><key>fft_filts</key><value>True</value></param>
<param><key>fft_rot</key><value>True</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/media/datqm/sdb2/downlink/file_05/</value></param>
<param><key>fc</key><value>1851200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Down"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_1</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/data/uplink/file_02/</value></param>
<param><key>fc</key><value>1859200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Up"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_1_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/data/uplink/file_03/</value></param>
<param><key>fc</key><value>1863200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Up"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_1_0_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/data/uplink/file_04/</value></param>
<param><key>fc</key><value>1847200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Up"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_1_0_0_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/data/uplink/file_05/</value></param>
<param><key>fc</key><value>1851200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Up"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_2</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/media/datqm/sdb2/downlink/file_02/</value></param>
<param><key>fc</key><value>1859200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Down"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_3</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/data/uplink/file_01/</value></param>
<param><key>fc</key><value>1855200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Up"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_4</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/media/datqm/sdb2/downlink/file_04/</value></param>
<param><key>fc</key><value>1847200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Down"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_5</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/media/datqm/sdb2/downlink/file_03/</value></param>
<param><key>fc</key><value>1863200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Down"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_sink</key>
<param><key>id</key><value>gsm_file_sink_6</value></param>
<param><key>append</key><value>False</value></param>
<param><key>bwd</key><value>samp_rate/5</value></param>
<param><key>file</key><value>/media/datqm/sdb2/downlink/file_01/</value></param>
<param><key>fc</key><value>1855200000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status</key><value>"Down"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_insert_db</key>
<param><key>id</key><value>gsm_insert_db_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hsn</value></param>
<param><key>label</key><value>hsn</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>id_start</value></param>
<param><key>label</key><value>ID start</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from grgsm import arfcn</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ma</value></param>
<param><key>label</key><value>MA list</value></param>
<param><key>value</key><value>[726,806,808,811]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>maio</value></param>
<param><key>label</key><value>maio</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>math_imp</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>math_imp_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n</value></param>
<param><key>label</key><value>Database name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>offsetCFile</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nstream</value></param>
<param><key>label</key><value>Number Stream</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OSR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>s</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.25e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>s1</value></param>
<param><key>label</key><value>samp_rate_in</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>25e6/9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_start</value></param>
<param><key>label</key><value>Sample Start</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>30099</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tseq</value></param>
<param><key>label</key><value>Traning Sequence</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tslot</value></param>
<param><key>label</key><value>Time Slot</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>1855.2e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>ant1</key><value></value></param>
<param><key>bw1</key><value>samp_rate</value></param>
<param><key>center_freq1</key><value>1761.4e6</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>gsm_decimator_ccf_1</source_block_id><sink_block_id>gsm_file_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_1</source_block_id><sink_block_id>gsm_file_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_1</source_block_id><sink_block_id>gsm_file_sink_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_1</source_block_id><sink_block_id>gsm_file_sink_1_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_1</source_block_id><sink_block_id>gsm_file_sink_1_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_2</source_block_id><sink_block_id>gsm_file_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_2</source_block_id><sink_block_id>gsm_file_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_2</source_block_id><sink_block_id>gsm_file_sink_5</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_2</source_block_id><sink_block_id>gsm_file_sink_4</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_decimator_ccf_2</source_block_id><sink_block_id>gsm_file_sink_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_file_sink_0</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_1</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_1_0</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_1_0_0</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_1_0_0_0</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_2</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_3</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_4</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_5</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>gsm_file_sink_6</source_block_id><sink_block_id>gsm_insert_db_0</sink_block_id><source_key>msg_out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gsm_decimator_ccf_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gsm_decimator_ccf_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
