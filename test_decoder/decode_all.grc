<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>decode_all</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gsm_symb_rate</value></param>
<param><key>value</key><value>1625000.0/6.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>-0.661913</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>value</key><value>gsm_symb_rate*osr</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>b</value></param>
<param><key>label</key><value>Band width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>base_port</value></param>
<param><key>label</key><value>base_port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>6700</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_2</value></param>
<param><key>samples_per_second</key><value>s</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_2_0</value></param>
<param><key>samples_per_second</key><value>s</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f</value></param>
<param><key>label</key><value>File Path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/datqm/Desktop/Share_Folder/Share_Folder/test_613.cfile</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>Frequency Center</value></param>
<param><key>value</key><value>[1848.4e6, 18644.4e6]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fn</value></param>
<param><key>label</key><value>Frame Number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>gsm_bcch_ccch_demapper</key>
<param><key>id</key><value>gsm_bcch_ccch_demapper_0</value></param>
<param><key>timeslot_nr</key><value>0</value></param>
</block>
<block>
<key>gsm_burst_file_sink</key>
<param><key>id</key><value>gsm_burst_file_sink_0_1_0</value></param>
<param><key>filename</key><value>/data/726</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_cx_channel_hopper</key>
<param><key>id</key><value>gsm_cx_channel_hopper_0</value></param>
<param><key>hsn</key><value>0</value></param>
<param><key>ma</key><value>[59]</value></param>
<param><key>maio</key><value>0</value></param>
</block>
<block>
<key>gsm_decode_cx</key>
<param><key>id</key><value>gsm_decode_cx_0</value></param>
<param><key>affinity</key><value>0,1,2,3,4,5</value></param>
<param><key>id_start</key><value>id_start</value></param>
<param><key>cell_allocation</key><value>[59]</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>sample_rate</key><value>s</value></param>
<param><key>table_name</key><value>n</value></param>
<param><key>tseq</key><value>tseq</value></param>
</block>
<block>
<key>gsm_file_source_C0</key>
<param><key>id</key><value>gsm_file_source_C0_0</value></param>
<param><key>f</key><value>947600000</value></param>
<param><key>offset</key><value>sample_start</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>uplink</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_file_source_C0</key>
<param><key>id</key><value>gsm_file_source_C0_0_5</value></param>
<param><key>f</key><value>950600000</value></param>
<param><key>offset</key><value>sample_start</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>uplink</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_0</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>False</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_rotator_cx</key>
<param><key>id</key><value>gsm_rotator_cx_0</value></param>
<param><key>bd</key><value>s</value></param>
<param><key>fc</key><value>[947.6e6]</value></param>
<param><key>id_start</key><value>id_start</value></param>
<param><key>cell_allocation</key><value>[59]</value></param>
<param><key>num_out</key><value>1</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>samp_in</key><value>s</value></param>
<param><key>sample_rate</key><value>s</value></param>
<param><key>table_name</key><value>726</value></param>
</block>
<block>
<key>gsm_rotator_cx</key>
<param><key>id</key><value>gsm_rotator_cx_0_0</value></param>
<param><key>bd</key><value>s</value></param>
<param><key>fc</key><value>[950.6e6]</value></param>
<param><key>id_start</key><value>id_start</value></param>
<param><key>cell_allocation</key><value>[73]</value></param>
<param><key>num_out</key><value>1</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>samp_in</key><value>s</value></param>
<param><key>sample_rate</key><value>s</value></param>
<param><key>table_name</key><value>726</value></param>
</block>
<block>
<key>gsm_rotator_cx</key>
<param><key>id</key><value>gsm_rotator_cx_0_0_0</value></param>
<param><key>bd</key><value>s</value></param>
<param><key>fc</key><value>[950.6e6]</value></param>
<param><key>id_start</key><value>id_start</value></param>
<param><key>cell_allocation</key><value>[75]</value></param>
<param><key>num_out</key><value>1</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>samp_in</key><value>s</value></param>
<param><key>sample_rate</key><value>s</value></param>
<param><key>table_name</key><value>726</value></param>
</block>
<block>
<key>gsm_rotator_cx</key>
<param><key>id</key><value>gsm_rotator_cx_0_0_0_0</value></param>
<param><key>bd</key><value>s</value></param>
<param><key>fc</key><value>[950.6e6]</value></param>
<param><key>id_start</key><value>id_start</value></param>
<param><key>cell_allocation</key><value>[82]</value></param>
<param><key>num_out</key><value>1</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>samp_in</key><value>s</value></param>
<param><key>sample_rate</key><value>s</value></param>
<param><key>table_name</key><value>726</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hsn</value></param>
<param><key>label</key><value>hsn</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>id_start</value></param>
<param><key>label</key><value>ID start</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ma</value></param>
<param><key>label</key><value>MA list</value></param>
<param><key>value</key><value>[59]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>maio</value></param>
<param><key>label</key><value>maio</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>math_imp</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n</value></param>
<param><key>label</key><value>Database name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>726</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nstream</value></param>
<param><key>label</key><value>Number Stream</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OSR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_0</value></param>
<param><key>nfilts</key><value>10</value></param>
<param><key>rrate</key><value>1625000*2/(6e6*0.6)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_1</value></param>
<param><key>nfilts</key><value>10</value></param>
<param><key>rrate</key><value>1625000*2/(6e6*0.6)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_3</value></param>
<param><key>nfilts</key><value>10</value></param>
<param><key>rrate</key><value>1625000*2/(6e6*0.6)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_3_2</value></param>
<param><key>nfilts</key><value>10</value></param>
<param><key>rrate</key><value>1625000*2/(6e6*0.6)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, s,125e3,5e3,firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, s,125e3,5e3,firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0_2</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, s,125e3,5e3,firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0_3</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>firdes.low_pass(1, s,125e3,5e3,firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>s</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sample_start</value></param>
<param><key>label</key><value>Sample Start</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>119830</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tseq</value></param>
<param><key>label</key><value>Traning Sequence</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tslot</value></param>
<param><key>label</key><value>Time Slot</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate_out</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>s</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>s</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_throttle_0_2</source_block_id><sink_block_id>gsm_rotator_cx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2_0</source_block_id><sink_block_id>gsm_rotator_cx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2_0</source_block_id><sink_block_id>gsm_rotator_cx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_2_0</source_block_id><sink_block_id>gsm_rotator_cx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_bcch_ccch_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_cx_channel_hopper_0</source_block_id><sink_block_id>gsm_bcch_ccch_demapper_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decode_cx_0</source_block_id><sink_block_id>gsm_burst_file_sink_0_1_0</sink_block_id><source_key>CX</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gsm_decode_cx_0</source_block_id><sink_block_id>gsm_cx_channel_hopper_0</sink_block_id><source_key>CX</source_key><sink_key>CX</sink_key></connection>
<connection><source_block_id>gsm_file_source_C0_0</source_block_id><sink_block_id>blocks_throttle_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_file_source_C0_0_5</source_block_id><sink_block_id>blocks_throttle_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_rotator_cx_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_rotator_cx_0_0</source_block_id><sink_block_id>pfb_decimator_ccf_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_rotator_cx_0_0_0</source_block_id><sink_block_id>pfb_decimator_ccf_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_rotator_cx_0_0_0_0</source_block_id><sink_block_id>pfb_decimator_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>gsm_decode_cx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_1</source_block_id><sink_block_id>gsm_decode_cx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_3</source_block_id><sink_block_id>gsm_decode_cx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_3_2</source_block_id><sink_block_id>gsm_decode_cx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_3_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0_2</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0_3</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
