<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gsm_input</value></param>
<param><key>author</key><value>Piotr Krysik</value></param>
<param><key>category</key><value></value></param>
<param><key>description</key><value>Adaptor of input stream for the GSM receiver. Contains frequency ofset corrector doing also resampling to integer multiplies of GSM sample rate and LP filter filtering GSM channel.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GSM input adaptor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gsm_symb_rate</value></param>
<param><key>value</key><value>1625000.0/6.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_out</value></param>
<param><key>value</key><value>gsm_symb_rate*osr</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>ctrl_in</value></param>
<param><key>label</key><value>ctrl_in</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>940e6</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>samp_rate_in/samp_rate_out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gsm_clock_offset_corrector_tagged</key>
<param><key>id</key><value>gsm_clock_offset_corrector_tagged_0</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>ppm</key><value>ppm</value></param>
<param><key>samp_rate_in</key><value>samp_rate_in</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>125e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_out</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>osr</value></param>
<param><key>label</key><value>OSR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate_in</value></param>
<param><key>label</key><value>samp_rate_in</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<connection><source_block_id>ctrl_in</source_block_id><sink_block_id>gsm_clock_offset_corrector_tagged_0</sink_block_id><source_key>out</source_key><sink_key>ctrl</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_corrector_tagged_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_clock_offset_corrector_tagged_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gsm_clock_offset_corrector_tagged_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
